## fsae_dash/package/Config.in
```kconfig
config BR2_PACKAGE_FSAE_DASH
    bool "FSAE Dash Custom Package"
    help
        Include fsae dash applications
```
